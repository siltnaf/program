# Keil uVision project stc15f104Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: stc15f104Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c STARTUP.A51
    ./Public/src/: Delay.c init.c process.c
